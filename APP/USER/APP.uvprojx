# Keil uVision project APP.uvprojx, settings and files
target HBP (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HBP +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,USE_GD_MCU1
  c misc: --C99
  c include: ..\CMSIS;..\FWlib\inc;..\USER;..\INC;..\FWlib\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group BSP
    ../BSP/: stm32f10x_it.c usart1.c bsp_adc.c bsp_i2c.c bsp_io.c
  group APP
    ../APP/: main.c shell.c
  group startup
    ../FWlib/startup/arm/: startup_stm32f10x_md.s
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_i2c.c misc.c stm32f10x_adc.c stm32f10x_dma.c
  group CMSIS
    ../FWlib/cmsis/: core_cm3.c system_stm32f10x.c
  group INC
    ../Inc/: i2c_ee.h stm32f10x_it.h usart1.h
    ../INC/: bsp_type.h user_val.h
